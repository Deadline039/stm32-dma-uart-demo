# Keil uVision project dma_uart_demo.uvprojx, settings and files
target dma_uart_demo (6210000::V6.21::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dma_uart_demo
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: STM32F103xE,USE_HAL_DRIVER
  c misc: -Wno-padded -Wno-unsafe-buffer-usage -Wno-reserved-identifier -Wno-missing-noreturn -Wno-covered-switch-default -Wno-switch-enum -Wno-missing-prototypes -Wno-newline-eof -Wno-gnu-pointer-arith -Wno-declaration-after-statement -Wno-sign-conversion -Wno-implicit-int-conversion -Wno-double-promotion -Wno-missing-field-initializers -Wno-undef -Wno-self-assign -Wno-extra-semi-stmt -Wno-missing-variable-declarations -Wno-cast-align -Wno-implicit-float-conversion -Wno-missing-braces -Wno-cast-qual -Wno-format-nonliteral -Wno-gnu-binary-literal
  c include: Drivers\CMSIS\Include;Drivers\STM32F1xx_HAL_Driver\Inc;Drivers\CMSIS\Device\ST\STM32F1xx\Include;User\Application\Inc;User\Bsp\Inc;.cmsis\include
  asm define: STM32F103xE,USE_HAL_DRIVER
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0xc000
  group Drivers/CMSIS
    Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/CMSIS/Startup
    Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Drivers/HAL_Driver
    Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c
  group User
    User/Application/Src/: main.c stm32f1xx_it.c
  group Bsp
    User/Bsp/Src/: bsp.c dma_uart.c key.c led.c retarget_io.c uart.c ring_fifo.c
